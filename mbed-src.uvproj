# Keil uVision project mbed-src.uvproj, settings and files
target MbedStm32F103VC (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mbed-src +hex
  AfterMake: fromelf --bin -o build\mbed-src_NUCLEO_F103RB.bin build\mbed-src.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_NUCLEO_F103RB,  MBED_BUILD_TIMESTAMP=1448174142.25,  TARGET_FF_MORPHO,  TARGET_CORTEX_M,  TOOLCHAIN_ARM_MICRO,  TARGET_STM32F1,  __MBED__=1,  ARM_MATH_CM3,  TARGET_STM,  __CORTEX_M3,  TARGET_M3,  TOOLCHAIN_ARM,  TARGET_STM32F103RB,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;api;hal;targets;targets/cmsis;targets/cmsis/TARGET_STM;targets/cmsis/TARGET_STM/TARGET_STM32F1;targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO;targets/hal;targets/hal/TARGET_STM;targets/hal/TARGET_STM/TARGET_STM32F1;targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;common;.\DeviceDriver\DHT21;.\DeviceDriver\28BYJ48;.\DeviceDriver\DS18B20;.\DeviceDriver\ESP8266;.\DeviceDriver\GP2Y1010au;.\fs\sd;.\fs\fat;.\fs\fat\ChaN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/stm32f103xb.sct
  group src
    targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/: startup_stm32f103xb.S sys.cpp
    targets/cmsis/TARGET_STM/TARGET_STM32F1/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
    targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: cmsis_nvic.c hal_tick.c system_stm32f1xx.c
    targets/hal/TARGET_STM/TARGET_STM32F1/: analogin_api.c gpio_api.c gpio_irq_api.c i2c_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: PeripheralPins.c
    common/: assert.c board.c error.c gpio.c lp_ticker_api.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c ticker_api.c us_ticker_api.c wait_api.c BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp CallChain.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp SPI.cpp SPISlave.cpp Serial.cpp SerialBase.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp retarget.cpp
  group User
    ./: main.cpp
  group DeviceDriver
    ./DeviceDriver/28BYJ48/: 28BYJ48.cpp
    ./DeviceDriver/DHT21/: Dht21.cpp
    ./DeviceDriver/GP2Y1010au/: GP2Y1010au.cpp
    ./DeviceDriver/ESP8266/: ESP8266_Usart.cpp
  group FileSystem
    ./fs/sd/: SDFileSystem.cpp
    ./fs/fat/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./fs/fat/ChaN/: ccsbcs.cpp diskio.cpp ff.cpp
